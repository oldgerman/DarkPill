# Repository oldgerman/DarkPill

File README.md:

# DarkPill

A STM32 development board Improved from [BluePill](https://stm32-base.org/boards/STM32F103C8T6-Blue-Pill)

.png)

.png)

### Notice：

Pin B1 is repeated twice (BOOT1 and PB1), this problem has been modified to B2 in the shared PCB file :)

## Features

- Support LQFP48 packages such as STM32F030, F072，F103，F303，G474...
- Pin to pin with BluePill development kits(Except B2).
- Double-sided PCB layout, the board thickness is 1.0mm, size 59.7mm x17.8mm, both pads and vias have teardrops...
- Center symmetrical design.
- Discrete components are packaged in 0603, which is easy to solder by hand.
- There are four M2 holes around the PCB that are easy to fix.
- USB C Connector  supports positive and negative insertion.
- Use the [USBLC6-2](https://www.st.com/en/protection-devices/usblc6-2.html) ic to ESD protection, Don't need to solder it  will not affect the serial port work.

## PCB

## SCH

## B.O.M

Please see bom/ibom.html or following:

| Num  | Qty  | Value          | Device                   | Package        | Parts                                                        |
| ---- | ---- | -------------- | ------------------------ | -------------- | ------------------------------------------------------------ |
| 1    | 1    | STM32F103CBT6  | STM32F303CBT6            | TQFP48         | U1                                                           |
| 2    | 1    | ME6211C33M5G-N | 3.3V 500mA LDO           | SOT23-5        | U2                                                           |
| 3    | 2    | USBLC6-2       | USBLC6-2-SOT23-6         | SOT23-6        | VD1, VD2                                                     |
| 4    | 1    | BAT54C         | BAT54C                   | SOT23-R        | VD3                                                          |
| 5    | 1    | B5819W         | B5819W-SOD323            | SOD-323        | D1                                                           |
| 6    | 1    | 500mA          | FUSE                     | 0603           | F1                                                           |
| 7    | 2    | LED            | LED_0603_MICRO           | 0603_LED       | LED1, LED2                                 LED               |
| 8    | 2    | 0R             | RESISTOR0603             | 0603           | R3, R14                                                      |
| 9    | 1    | 10R            | RESISTOR0603             | 0603           | R13                                        Resistors         |
| 10   | 2    | 22R            | RESISTOR0603             | 0603           | R5, R6                                                       |
| 11   | 4    | 2.2K           | RESISTOR0603             | 0603           | R4, R7, R11, R12                                             |
| 12   | 3    | 10K            | RESISTOR0603             | 0603           | R1, R2, R9                                                   |
| 13   | 2    | 100K           | RESISTOR0603             | 0603           | R8, R15                                                      |
| 14   | 1    | 10M            | RESISTOR0603             | 0603           | R10                                                          |
| 15   | 2    | 6.8pF          | CAP_CERAMIC0603          | 0603           | C6, C7                                                       |
| 16   | 2    | 10pF           | CAP_CERAMIC0603          | 0603           | C8, C9                                                       |
| 17   | 9    | 100nF          | CAP_CERAMIC0603          | 0603           | C1, C2, C3, C10, C11, C12,   C13, C14, C15                   |
| 18   | 2    | 1uF            | CAP_CERAMIC0603          | 0603           | C4, C5                                                       |
| 19   | 1    | 8/12/16MHz     | 3225_CRYSTALL            | 3.2X2.5_KX-7   | ZO1                                                          |
| 20   | 1    | 32.768kHz      | KX-327-NHF      CRYSTALL | 3.2X1.5        | ZO2                                                          |
| 21   | 2    | SWITCH_3X4_SMD | SWITCH_3X4_SMD           | SWITCH_3X4_SMD | S1, S2                                                       |
| 22   | 1    |                | USB_C2-LAYER             | USB-C-16P      | J1                                       USB   Type C 16Pin Connector |
| 23   | 2    |                | CONN_20                  | 1X20           | J2, J3                                                       |
| 24   | 1    |                | CONN_04PTH               | 1X4            | J4                                                           |

## Notice

### EN

If the U1 chip is STM32F103 and Programming [STM32duino-bootloader](https://github.com/rogerclarkmelbourne/STM32duino-bootloader) with [Arduino_STM32](https://github.com/rogerclarkmelbourne/Arduino_STM32) for DFU upgrade, the frequency of 3225 crystal oscillator must be 8, 12 or 16MHz, because these frequencies can be divisible by the [USB clock of 48Mhz](https://www.sigidwiki.com/wiki/High_Speed_USB_Noise). In order to save a lot of trouble, it is best to use an 8MHz crystal oscillator, but the 3225 package may not be easy to reach, such as [KDS DSX321G](http://ftp.kds.info/products/DSX321G_en.pdf).

If you use 12 or 16MHz, you need to build an arm tool chain and use make to recompile STM32duino-bootloader. Fortunately, I have compiled 12MHz and 16MHz STM32duino-bootloader, you can use it directly. However, it is not enough to just burn it, you also need to change the PLL multiplier value in boards_setup.cpp in the ArduinoSTM32 folder. [See here for details](https://oldgerman.github.io/201e530f/).

### ZH

若U1芯片为STM32F103，并且烧录[STM32duino-bootloader](https://github.com/rogerclarkmelbourne/STM32duino-bootloader)配合[Arduino_STM32](https://github.com/rogerclarkmelbourne/Arduino_STM32)以进行DFU升级，那么3225晶振的频率必须为8、12或16MHz，因为这些频率可以被[USB时钟48Mhz](https://www.cnblogs.com/cherishui/p/4204280.html)整除。为了省去很多麻烦，最好使用8MHz的晶振，但是3225封装的可能不太好买到，例如[KDS DSX321G](http://ftp.kds.info/products/DSX321G_en.pdf)。

若使用12或16MHz，需要搭建arm工具链，使用make重新编译STM32duino-bootloader，幸运的是，我已经编译好了12MHz和16MHz的STM32duino-bootloader，你可以直接使用。但是，仅仅烧录它是不够的，还需要改动ArduinoSTM32文件夹里的boards_setup.cpp中的PLL倍频的值，[步骤详见此处](https://oldgerman.github.io/201e530f/)。

## Test

### Programming methods

#### 1. Serial

| Connection                                          | 1.Arduino IDE                                             | 2.FlyMCU                                                  |
| --------------------------------------------------- | --------------------------------------------------------- | --------------------------------------------------------- |
|  | .png) | .png) |

#### 2. SWD(ST-LINK)

| Connection                                    | 1.Arduino IDE                                       | 2.STM32 ST-LINK Utility                             |
| --------------------------------------------- | --------------------------------------------------- | --------------------------------------------------- |
|  | .png) | .png) |

#### 3. DFU 

#### STM32F103

| Connection                                    | 1.Arduino IDE(with STM32duino-bootloader)           | 2.DfuSeDemo                                                  |
| --------------------------------------------- | --------------------------------------------------- | ------------------------------------------------------------ |
|  | .png) | [stm32-dfu-bootloader](https://github.com/davidgfnet/stm32-dfu-bootloader)<b>Not yet successful. |

#### <span style="color:#FF0000;">Notice:</span>

Both using Serial or ST-LINK programming with STM32duino-bootloader will disable the STM32duino-bootloader DFU function, and the symptoms are: the LED of PC13 cannot flash after Reset is pressed.:flushed:

在STM32duino-bootloader下使用串行或ST-LINK编程都将禁用STM32duino-bootloader DFU功能，其症状为：按下Reset后PC13的LED无法闪烁.:flushed:

#### STM32F072

| U1                                    | DFU                                   | DfuSeDemo                             |
| ------------------------------------- | ------------------------------------- | ------------------------------------- |
| .png) | .png) | .png) |

### RTC

## EAGLE design Eagle PCB Files/DarkPill_V1.1_eagle_V7.6.brd

Parts:
C1, C2, C3, C10, C11, C12, C13, C14, C15: 100nF; 0603
C4, C5: 1uF; 0603
C6, C7: 6pF; 0603
C8, C9: 10pF; 0603
D1: B5819W; SOD-323
F1: 500mA; 0603
J1: USB_C2-LAYER; USB-C-16P
J2, J3: CONN_20; 1X20
J4: CONN_04PTH; 1X04
LED1, LED2: LED_0603_MICRO; 0603_LED
R1, R2, R9: 10K; 0603
R3, R14: 0R; 0603
R4, R7, R11, R12: 2.2K; 0603
R5, R6: 22R; 0603
R8, R15: 100K; 0603
R10: 10M; 0603
R13: 10R; 0603
S1, S2: SWITCH_3X4_SMD
U1: STM32F103CBT6; TQFP48
U2: ME6211C33M5G-N; SOT23-5
VD1, VD2: USBLC6-2; SOT23-6
VD3: BAT54C; SOT23-R
ZO1: 12MHz; 3.2X2.5_KX-7
ZO2: 32.768kHz; 3.2X1.5

Connections:
+3V3: C2.1, C5.1, C12.2, C13.2, C14.2, C15.1, J2.1, J3.18, J4.1, LED1.1 (A), LED2.1 (A), R4.2, R9.1, R13.2, S1.2, U1.24 (VDD_1), U1.36 (VDD_2), U1.48 (VDD_3), U2.5 (OUT), VD1.5, VD2.5, VD3.1 (A1)
+5V: C1.1, C4.1, D1.C, J2.3, U2.1 (IN), U2.3 (CE)
+BATT: J3.1, VD3.2 (A2)
AGND: C11.1, R14.1, U1.8 (VSSA/VREF-)
BOOT0: R7.1, R8.1, U1.44 (BOOT0)
CC1: J1.A5 (CC1), R1.1
CC2: J1.B5 (CC2), R2.1
D+: J1.A6 (D+), J1.B6 (D+), R4.1, R5.1, VD1.3, VD1.4
D-: J1.A7 (D-), J1.B7 (D-), R6.1, VD1.1, VD1.6
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.1, C8.1, C9.1, C10.2, C12.1, C13.1, C14.1, C15.2, J1.GND, J1.GND2 (GND), J2.2, J3.20, J4.4, R1.2, R2.2, R3.1, R8.2, R12.2, R14.2, S2.1, U1.23 (VSS_1), U1.35 (VSS_2), U1.47 (VSS_3), U2.2 (GND), VD1.2, VD2.2, ZO1.2, ZO1.4
unnamed: LED1.2 (C), R11.1
unnamed: R7.2, S1.1
unnamed: LED2.2 (C), R12.1
unnamed: R15.1, U1.20 (PB2)
unnamed: D1.A, F1.2
unnamed: C11.2, R13.1, U1.9 (VDDA)
NRST: C3.1, J3.17, R9.2, S2.2, U1.7 (NRST)
OSC_IN: C8.2, U1.5 (PF0/OSC_IN), ZO1.3
OSC_OUT: C9.2, U1.6 (PF1/OSC_OUT\), ZO1.1
PA0: J3.5, U1.10 (PA0)
PA1: J3.6, U1.11 (PA1)
PA2: J3.7, U1.12 (PA2)
PA3: J3.8, U1.13 (PA3)
PA4: J3.9, U1.14 (PA4)
PA5: J3.10, U1.15 (PA5)
PA6: J3.11, U1.16 (PA6)
PA7: J3.12, U1.17 (PA7)
PA8: J2.16, U1.29 (PA8)
PA9: J2.15, U1.30 (PA9)
PA10: J2.14, U1.31 (PA10)
PA11/USB_DM: J2.13, R6.2, U1.32 (PA11)
PA12/USB_DP: J2.12, R5.2, U1.33 (PA12)
PA13/SWDIO: J4.2, U1.34 (PA13), VD2.1, VD2.6
PA14/SWCLK: J4.3, U1.37 (PA14), VD2.3, VD2.4
PA15: J2.11, U1.38 (PA15)
PB0: J3.13, U1.18 (PB0)
PB1: J3.14, U1.19 (PB1)
PB2/B00T1: J3.19, R15.2
PB3: J2.10, U1.39 (PB3)
PB4: J2.9, U1.40 (PB4)
PB5: J2.8, U1.41 (PB5)
PB6: J2.7, U1.42 (PB6)
PB7: J2.6, U1.43 (PB7)
PB8: J2.5, U1.45 (PB8)
PB9: J2.4, U1.46 (PB9)
PB10: J3.15, U1.21 (PB10)
PB11: J3.16, U1.22 (PB11)
PB12: J2.20, U1.25 (PB12)
PB13: J2.19, U1.26 (PB13)
PB14: J2.18, U1.27 (PB14)
PB15: J2.17, U1.28 (PB15)
PC13: J3.2, R11.2, U1.2 (PC13)
PC14/OSC32_IN: C7.2, J3.3, R10.2, U1.3 (PC14/OSC32_IN), ZO2.2
PC15/OSC32_OUT: C6.2, J3.4, R10.1, U1.4 (PC15/OSC32_OUT), ZO2.1
SHLD: J1.SHLD1 (SHLD), J1.SHLD2 (SHLD), J1.SHLD3 (SHLD), J1.SHLD4 (SHLD), J1.SHLD5 (SHLD), J1.SHLD6 (SHLD), J1.SHLD7 (SHLD), J1.SHLD8 (SHLD), R3.2
VBAT_PRO: C10.1, U1.1 (VBAT), VD3.3 (C)
VBUS: F1.1, J1.VBUS1 (VBUS), J1.VBUS2 (VBUS)

Notes on the sheet:
可以由内部电源供电也可以仅外部供电 Can be powered by internal power supply or external power supply only
OldGerman

Board: 2 copper layers, 59.7 x 17.8 mm, 50 parts (21 on the bottom side), 57 nets.

Other parts of the board:
U$1, U$2: OSHW-LOGO-MINI
U$3: CREATIVE_COMMONS

## Commit log

2020-08-14 frist commit
2020-08-14 2nd commit
2020-08-14 3nd commit
2020-08-14 4nd commit
2020-08-14 5nd commit
2020-08-15 add eagle_v7.6
2020-08-15 eAdd agle V7.66
2020-08-16 Add agle V7.66
2020-08-20 Add V1.1
2020-08-20 Add V1.1 and F072 DFU
2020-11-20 images

Notices in the files:
parts and their libraries:
microbuilder: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
SparkFun-Connectors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
